## boards/shields/fishy36/Kconfig.defconfig
```kconfig
if SHIELD_FISHY36

config ZMK_KEYBOARD_NAME
    default "Fishy36"

endif # SHIELD_FISHY36
```
